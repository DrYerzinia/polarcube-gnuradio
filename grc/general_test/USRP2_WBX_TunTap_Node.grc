<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>baud_rate</value></param>
<param><key>choices</key><value>[115200, 76800, 38400,19200,9600]</value></param>
<param><key>value</key><value>9600</value></param>
<param><key>grid_pos</key><value>(0,2,1,1)</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>labels</key><value>["115K2","76K8", "38K4", "19K2","9K6"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>doppler_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>sat_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(1,0,1,1)</value></param>
<param><key>label</key><value>Doppler Frequency</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>(0,1,2,1)</value></param>
<param><key>label</key><value>Manual Frequency Correction</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>num_steps</key><value>500</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>115000</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>rx_callsign</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"KD0WGV-2"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(2,3,1,1)</value></param>
<param><key>label</key><value>RX Callsign</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>460800</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>sat_callsign</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"KD8SPS-1"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(1,3,1,1)</value></param>
<param><key>label</key><value>Satellite Callsign</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>sat_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>437480000</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(0,0,1,1)</value></param>
<param><key>label</key><value>Satellite Frequency</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>station_callsign</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"KD0WGV-1"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(0,3,1,1)</value></param>
<param><key>label</key><value>Station Callsign</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>variable_text_box_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>doppler_freq-sat_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(2,0,1,1)</value></param>
<param><key>label</key><value>Doppler Shift</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>istunflag</key><value>True</value></param>
<param><key>ifn</key><value>tun0</value></param>
<param><key>mtu</key><value>256</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_1</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x00</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.35</value></param>
<param><key>log</key><value>True</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>len</key><value>16</value></param>
<param><key>mask</key><value>0x21</value></param>
<param><key>seed</key><value>0x0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>doppler_freq-sat_freq-freq_corr-lo_offset</value></param>
<param><key>decim</key><value>samp_rate/(baud_rate*2)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,baud_rate/2,baud_rate/10)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>-doppler_freq+sat_freq-freq_corr+lo_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>samp_rate/(baud_rate*2)</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,baud_rate/2,5000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Receive Chain</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Transmit Chain</value></param>
</block>
<block>
<key>spacegrant_DeNRZI</key>
<param><key>id</key><value>spacegrant_DeNRZI_0_0</value></param>
</block>
<block>
<key>spacegrant_NRZI</key>
<param><key>id</key><value>spacegrant_NRZI_0</value></param>
</block>
<block>
<key>spacegrant_ax25_pdu_packer</key>
<param><key>id</key><value>spacegrant_ax25_pdu_packer_0</value></param>
<param><key>dest_addr</key><value>KD0WGV-2</value></param>
<param><key>src_addr</key><value>KD0WGV-1</value></param>
</block>
<block>
<key>spacegrant_ax25_pdu_unpacker</key>
<param><key>id</key><value>spacegrant_ax25_pdu_unpacker_0</value></param>
<param><key>addr_filt</key><value>3</value></param>
<param><key>dest_addr</key><value>KD0WGV-1</value></param>
<param><key>src_addr</key><value>KD0WGV-2</value></param>
</block>
<block>
<key>spacegrant_hdlc_deframer</key>
<param><key>id</key><value>spacegrant_hdlc_deframer_0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>10</value></param>
<param><key>validate_crc</key><value>True</value></param>
</block>
<block>
<key>spacegrant_hdlc_deframer</key>
<param><key>id</key><value>spacegrant_hdlc_deframer_0_0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>10</value></param>
<param><key>validate_crc</key><value>True</value></param>
</block>
<block>
<key>spacegrant_hdlc_framer</key>
<param><key>id</key><value>spacegrant_hdlc_framer_0</value></param>
<param><key>frame_tag_name</key><value></value></param>
<param><key>number_of_flags</key><value>30</value></param>
</block>
<block>
<key>spacegrant_invert_bit</key>
<param><key>id</key><value>spacegrant_invert_bit_0_0</value></param>
</block>
<block>
<key>spaegrant_sat_doppler_correction</key>
<param><key>id</key><value>spaegrant_sat_doppler_correction_0</value></param>
<param><key>elevation</key><value>1646</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>latitude</key><value>40.007656</value></param>
<param><key>longitude</key><value>-105.261808</value></param>
<param><key>sat_freq</key><value>sat_freq</value></param>
<param><key>tle1</key><value>1 40379U 15003D   17309.82396510  .00002475  00000-0  11346-3 0  9992</value></param>
<param><key>tle2</key><value>2 40379  99.1156 159.3073 0139443 262.1186  96.4193 15.13579114152304</value></param>
<param><key>target</key><value>doppler_freq</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>sat_freq+lo_offset</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>184.32e6</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>sat_freq+lo_offset</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>184.32e6</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>doppler_freq+freq_corr</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>(4,2,1,2)</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>baud_rate*2</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>doppler_freq+freq_corr</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>(4,0,1,2)</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-70</value></param>
<param><key>samp_rate</key><value>baud_rate*2</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>sat_freq-lo_offset</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>(3,0,1,4)</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-50</value></param>
<param><key>samp_rate</key><value>460800</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_1_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>blocks_tuntap_pdu_0</source_block_id><sink_block_id>spacegrant_ax25_pdu_packer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_1</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>spacegrant_DeNRZI_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_scrambler_bb_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spacegrant_DeNRZI_0_0</source_block_id><sink_block_id>spacegrant_hdlc_deframer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spacegrant_DeNRZI_0_0</source_block_id><sink_block_id>spacegrant_invert_bit_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spacegrant_NRZI_0</source_block_id><sink_block_id>digital_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spacegrant_ax25_pdu_packer_0</source_block_id><sink_block_id>spacegrant_hdlc_framer_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>spacegrant_ax25_pdu_unpacker_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>spacegrant_hdlc_deframer_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>spacegrant_hdlc_deframer_0</source_block_id><sink_block_id>spacegrant_ax25_pdu_unpacker_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>spacegrant_hdlc_deframer_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>spacegrant_hdlc_deframer_0_0</source_block_id><sink_block_id>spacegrant_ax25_pdu_unpacker_0</sink_block_id><source_key>out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>spacegrant_hdlc_framer_0</source_block_id><sink_block_id>spacegrant_NRZI_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spacegrant_invert_bit_0_0</source_block_id><sink_block_id>spacegrant_hdlc_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
